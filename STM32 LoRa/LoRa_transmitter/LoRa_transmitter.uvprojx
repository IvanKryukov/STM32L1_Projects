# Keil uVision project LoRa_transmitter.uvprojx, settings and files
target STM32L100 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRa_transmitter
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS\Include;..\..\CMSIS\Device\ST\STM32L1xx\Include;..\..\CMSIS\Device\ST\STM32L1xx\Source\Templates;..\..\STM32L1xx_StdPeriph_Driver;..\..\STM32L1xx_StdPeriph_Driver\inc;..\..\STM32L1xx_StdPeriph_Driver\src;..\..\STM32 LoRa;..\LoRa_transmitter;..\..\..\STM32L1_Projects
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../../CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_mdp.s
  group CMSIS
    ../../CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../../CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
  group StdPeriph
    ../../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    ../../CMSIS/Device/ST/STM32L1xx/Include/: system_stm32l1xx.h
  group User
    ./: main.c
    ../: LoRa.c
